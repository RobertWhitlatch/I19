# Keil uVision project Remote.uvproj, settings and files
target Remote (ARM-ADS)
  device: LM4F120H5QR Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: Remote
  c flags: Optim=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c misc: --C99
  c include: .\include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./source/: RemoteMain.c ADC.c GPIO.c xBee.c SysTick.c
  group Environment
    ./source/: Output.c PLL.c startup.s Main.c
